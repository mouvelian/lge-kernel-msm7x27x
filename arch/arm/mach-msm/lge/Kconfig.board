## arch/arm/mach-msm/lge/Kconfig.board
```kconfig
#
# Inlcude the specific Kconfig file for LGE board
#

# LGE E0 Model
source "arch/arm/mach-msm/lge/e0/Kconfig"
```
